DESCRIPTION = "DAMC-FMC1Z7IO Headless Linux Image"

IMAGE_AUTOLOGIN = "0"

require recipes-core/images/techlab-headless.inc
require z7io-demo.inc
