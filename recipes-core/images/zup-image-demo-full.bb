DESCRIPTION = "DAMC-FMC2ZUP Full Linux Image"

IMAGE_AUTOLOGIN = "0"

require recipes-core/images/techlab-full.inc
require zup-demo.inc
