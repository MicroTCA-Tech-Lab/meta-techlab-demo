DESCRIPTION = "DAMC-MOTCTRL Headless Linux Image"

IMAGE_AUTOLOGIN = "0"

require recipes-core/images/techlab-headless.inc
