DESCRIPTION = "DAMC-FMC2ZUP Headless Linux Image"

IMAGE_AUTOLOGIN = "0"

require recipes-core/images/techlab-headless.inc
require zup-demo.inc
