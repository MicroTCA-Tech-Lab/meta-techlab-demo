DESCRIPTION = "DAMC-FMC1Z7IO Full Linux Image"

IMAGE_AUTOLOGIN = "0"

require recipes-core/images/techlab-full.inc
require z7io-demo.inc
